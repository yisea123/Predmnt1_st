# Keil uVision project Project.uvprojx, settings and files
target PREDMNT1_PredictiveMaintenance (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NUCLEO-F446RE_PredictiveMaintenance.bin +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32F4XX_NUCLEO,STM32_NUCLEO,__FPU_PRESENT=1U,ARM_MATH_CM4
  c include: ..\Inc;..\Patch;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\Drivers\BSP\X-NUCLEO-CCA02M1;..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1;..\..\..\..\..\Drivers\BSP\IKS01A2;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\Components\ism330dlc;..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\Middlewares\ST\STM32_MotionSP_Library\Inc;..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc;..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes;..\..\..\..\..\Middlewares\ST\BlueNRG-MS\hci\hci_tl_patterns\Basic;..\..\..\..\..\Middlewares\ST\BlueNRG-MS\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ./: startup_stm32f446xx.s
  group User/Patch
    ../Patch/: iks01a2_motion_sensors_ex_Patch.c iks01a2_motion_sensors_Patch.c ism330dlc_Patch.c
  group User
    ../Src/: console.c hci_tl_interface.c main.c MotionSP_Manager.c nucleo_f446re_bus.c OTA.c sensor_service.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_UART.c TargetPlatform.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/IKS01A2
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
    ../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
  group Drivers/BSP/Components/ism330dlc
    ../../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-CCAM02M1
    ../../../../../Drivers/BSP/X-NUCLEO-CCA02M1/: x_nucleo_cca02m1_audio.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../Drivers/BSP/IKS01A2/: iks01a2_env_sensors.c iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c
  group Middlewares/BlueNRG-MS
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/ST/STM32_Audio_PDM
    ../../../../../../../FP-IND-PREDMNT1/Firmware/Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/ST/STM32_MotionSP_Library
    ../../../../../Middlewares/ST/STM32_MotionSP_Library/Src/: MotionSP.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
